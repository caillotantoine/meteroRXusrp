<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>author</key><value>Antoine CAILLOT</value></param>
<param><key>comment</key><value>This work is based on the airspy_m2_lrpt_rx.grc of Otti.

Before run:
Select a path to save the output file in th efollowing block --&gt;</value></param>
<param><key>description</key><value>Demodulator of Meteor M2 satellites</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Meteor M2 Receiver 4 USRP (QT) </value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>clock_alpha</value></param>
<param><key>value</key><value>0.001</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@2 : 3,0,1,1</value></param>
<param><key>label</key><value>Clock alpha</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.001</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>0.01</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim_factor</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>file_path</value></param>
<param><key>value</key><value>path_to_save_dir + "/LRPT_" + datetime.now().strftime("%d%m%Y_%H%M")+".s"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>path_to_save_dir</value></param>
<param><key>value</key><value>os.path.expanduser("~/Desktop")</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>pll_alpha</value></param>
<param><key>value</key><value>0.015</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@2 : 4,0,1,1</value></param>
<param><key>label</key><value>PLL alpha</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.001</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>0.100</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>record</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@0 : 0,3,1,1</value></param>
<param><key>label</key><value>Raw I/Q Record</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@0 : 0,0,1,2</value></param>
<param><key>label</key><value>RF input gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>5</value></param>
<param><key>stop</key><value>65</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>137.1e6</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@0 : 0,2,1,1</value></param>
<param><key>label0</key><value>137.1 MHz</value></param>
<param><key>label1</key><value>137.9 MHz</value></param>
<param><key>label2</key><value>Test FM</value></param>
<param><key>label</key><value>RX Frequency</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>137.1e6</value></param>
<param><key>option1</key><value>137.9e6</value></param>
<param><key>option2</key><value>101.8e6</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_freq_old</value></param>
<param><key>value</key><value>137.1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_sec</value></param>
<param><key>value</key><value>(signal_samp_rate * 1.0) / (symbol_rate * 1.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>signal_samp_rate</value></param>
<param><key>value</key><value>140e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>72000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_samp_rate</value></param>
<param><key>value</key><value>signal_samp_rate*decim_factor</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>USRP</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>usrp_samp_rate</value></param>
<param><key>center_freq0</key><value>rx_freq+signal_samp_rate</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>True</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>usrp_samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>stream_args</key><value>peak=0.003906</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>analog_agc_xx_0</value></param>
<param><key>comment</key><value>doit être au bon samp_rate</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>4e3</value></param>
<param><key>rate</key><value>100e-3</value></param>
<param><key>reference</key><value>500e-3</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_rail_ff</key>
<param><key>id</key><value>analog_rail_ff_0</value></param>
<param><key>hi</key><value>1</value></param>
<param><key>lo</key><value>-1</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>signal_samp_rate</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>usrp_samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>file_path</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>127</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_mute_xx</key>
<param><key>id</key><value>blocks_mute_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>mute</key><value>record</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_1</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
<param><key>file</key><value>file_path+"_rawIQ.wav"</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>int(usrp_samp_rate/decim_factor)</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>clock_alpha</value></param>
<param><key>gain_omega</key><value>clock_alpha**2/4.0</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>samp_per_sec</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_constellation_soft_decoder_cf</key>
<param><key>id</key><value>digital_constellation_soft_decoder_cf_0</value></param>
<param><key>constellation</key><value>digital.constellation_calcdist(([-1-1j, -1+1j, 1+1j, 1-1j]), ([0, 1, 3, 2]), 4, 1).base()</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>pll_alpha</value></param>
<param><key>order</key><value>4</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from datetime import datetime</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import os.path</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1_0</value></param>
<param><key>import</key><value>import os.path</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>signal_samp_rate</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>2</value></param>
<param><key>samp_rate</key><value>usrp_samp_rate</value></param>
<param><key>width</key><value>25e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@2 : 0,0,3,1</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1.0 / symbol_rate</value></param>
<param><key>xmax</key><value>1</value></param>
<param><key>xmin</key><value>-1</value></param>
<param><key>ymax</key><value>1</value></param>
<param><key>ymin</key><value>-1</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>signal_samp_rate</value></param>
<param><key>fc</key><value>rx_freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@1 : 0,0,1,1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>bw</key><value>usrp_samp_rate</value></param>
<param><key>fc</key><value>rx_freq+signal_samp_rate</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@0 : 1,0,1,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>Filtered</value></param>
<param><key>label2</key><value>Shifted</value></param>
<param><key>color3</key><value>"black"</value></param>
<param><key>label3</key><value>RAW</value></param>
<param><key>name</key><value>Centered on RAW signal</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>qtgui_tab_widget_0</value></param>
<param><key>label0</key><value>Reception</value></param>
<param><key>label1</key><value>Demodulation</value></param>
<param><key>label2</key><value>Decoding</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>signal_samp_rate</value></param>
<param><key>fc</key><value>rx_freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@0 : 2,0,1,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_max</key><value>-30</value></param>
<param><key>int_min</key><value>-100</value></param>
<param><key>color1</key><value>6</value></param>
<param><key>name</key><value>Shifted signal</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>decim_factor</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>alpha</key><value>0.6</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>ntaps</key><value>361</value></param>
<param><key>samp_rate</key><value>signal_samp_rate</value></param>
<param><key>sym_rate</key><value>symbol_rate</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>usrp_samp_rate</value></param>
<param><key>freq0</key><value>rx_freq-signal_samp_rate</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>10</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>usrp_samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>USRP</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>USRP</source_block_id><sink_block_id>blocks_mute_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>USRP</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_rail_ff_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_wavfile_sink_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_wavfile_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_mute_xx_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_constellation_soft_decoder_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_soft_decoder_cf_0</source_block_id><sink_block_id>analog_rail_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>analog_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_mute_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
</flow_graph>
